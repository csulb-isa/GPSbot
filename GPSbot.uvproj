# Keil uVision project GPSbot.uvproj, settings and files
target GPSbot (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: GPSbot
  AfterMake: fromelf --bin --output=E:/GPSbot.bin ./Output/GPSbot.axf
  c flags: Optim=3
  c define: TARGET_LPC1768
  c include: ..\GPSbot;.\Source;.\mbedLibrary\lib26\LPC1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\Source\mbedLibrary\lib26\LPC1768\LPC1768.sct
  group Source
    ./Source/: main.cpp pccomm.cpp
  group Object
    C:/Embedded Design/Arm Projects/Cortex M3/Projects/GPSbot/Source/mbedLibrary/lib26/LPC1768/: cmsis_nvic.o core_cm3.o stackheap.o startup_LPC17xx.o system_LPC17xx.o
  group Library
    C:/Embedded Design/Arm Projects/Cortex M3/Projects/GPSbot/Source/mbedLibrary/lib26/LPC1768/: capi.ar mbed.ar
  group Drivers
    ./Source/Resources/compass/: cdcompass.cpp
    ./Source/Resources/gps/: CGps.cpp CNmea.cpp
    ./Source/Resources/servo/: CServo.cpp
    ./Source/Resources/sonar/: CSrf05.cpp
    ./Source/Resources/motor control/: CSpeed.cpp
    ./Source/Resources/serial/: CBuffer.cpp CUart0.cpp CUart1.cpp CUart2.cpp CUart3.cpp
    ./Source/Resources/ir distance/: C2y0a700.cpp
